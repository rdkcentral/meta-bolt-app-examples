SUMMARY = "Firebolt egl test app bolt image"

inherit base-bolt-image

IMAGE_INSTALL += "firebolt-egl-test"
